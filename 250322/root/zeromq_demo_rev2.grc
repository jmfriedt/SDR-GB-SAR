options:
  parameters:
    generate_options: no_gui
    id: zeromq_demo_rev2
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: f
  id: variable
  parameters:
    value: 5.5e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: samp_rate//10
    type: complex
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph    
      def jmf_server(self):                                                                           
          sock=socket.socket(socket.AF_INET, socket.SOCK_STREAM)                                      
          sock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)                                  
          sock.bind(('localhost', 5556))                                                              
          print("Server running")                                                                     
          sock.listen(1)                                                                              
          conn, addr = sock.accept()                                                                  
          with conn:                                                                                  
              print('connected from ',addr)                                                           
              while True:                                                                             
                   data=conn.recv(1)                                                                  
                   print(data)                                                                        
                   if '+' in str(data):                                                               
                      self.f=self.f+5000000                                                           
                   if '-' in str(data):                                                               
                      self.f=self.f-5000000                                                           
                   if 's' in str(data):                                                               
                      self.f=int(2412e6-3.125e6)                                                      
                   if '.' in str(data):                                                               
                      self.f=self.f                                                                   
                      print('Reprogram')                                                              
                   if 'q' in str(data):                                                               
                      print('Bye')                                                                    
                      sock.shutdown(socket.SHUT_RDWR)                                                 
                      sock.close()                                                                    
                   print(self.f)                                                                      
                   self.set_f(self.f)
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import threading
      print("Starting server")
      threading.Thread(target=epy_module_0.jmf_server,args=(self)).start()
    section: main_after_init
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: f
    center_freq1: f
    gain0: '70'
    gain1: '70'
    nchan: '2'
    otw: sc16
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
    vlen: samp_rate//10
  states: {}

connections:
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_interleave_0, '0', blocks_head_0, '0']
- [blocks_stream_to_vector_0, '0', zeromq_pub_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_interleave_0, '0']
- [uhd_usrp_source_0, '1', blocks_interleave_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
